# Repository SAOKnight/MP2905

## KiCad design MP2905.kicad_pcb

Parts:
C1, C4: 10nF; C_0603_1608Metric
C2: 4.7μF; C_0603_1608Metric
C3, C13: 100nF; C_0603_1608Metric
C5: 470UF; CP_Elec_10x7.7
C6: 10NF; C_0603_1608Metric
C7, C8: 4.7UF; C_1206_3216Metric
C9, C10: 100UF; C_1206_3216Metric
C11: 470uF; CP_Elec_10x7.7
C14: 22nF; C_0603_1608Metric
C15: 1μF; C_0603_1608Metric
D1: 1N4148WS; D_SOD-323
L1: L; PQ2010
Q1, Q2, Q3: NMOS; TDSON-8_L5.9-W5.2-P1.27-BL
R1: 1K; R_0603_1608Metric
R2: 3K; R_0603_1608Metric
R3: 2K; R_0603_1608Metric
R4: 20K; R_0603_1608Metric
R5: 20R; R_0603_1608Metric
R6: 10R; R_0603_1608Metric
SW1: SW_Nidec_CAS-120A1; SW-TH_SHOU-HAN_SS12D10G4
U1: MP2905EK-LF-P; MSOP10_MP2905_MNP

Connections:
+12V: C4.2, C5.1, C6.1, C7.1, C8.1, C13.2, Q1.1 (D), R2.2, SW1.2 (B), SW1.3 (A), U1.9 (IN)
/EN: Q3.2 (G), R4.2, SW1.1 (C)
/HG: D1.1 (K), R5.2, U1.8 (HG)
/LG: Q2.2 (G), U1.5 (LG)
/SW: C3.2, L1.1, Q1.3 (S), Q2.1 (D), R3.2, U1.7 (SW)
/VOUT: C9.1, C10.1, C11.1, L1.2, R6.1
GND: C1.1, C2.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C13.1, C15.1, Q2.3 (S), Q3.3 (S), R1.1, R4.1, U1.4 (GND)
unnamed: C14.1, R6.2
unnamed: D1.2 (A), Q1.2 (G), R5.1
unnamed: C1.2, Q3.1 (D), U1.2 (SS)
unnamed: C3.1, U1.6 (BST)
unnamed: C14.2, C15.2, R1.2, R3.1, U1.1 (FB)
unnamed: C4.1, R2.1, U1.10 (ILIM)
unnamed: C2.2, U1.3 (REF)

Notes on the sheet:
其中 VFB = 0.590V，RDC 是输出电感的直流电阻， ILOAD 是满载电流，0.5*ILOAD 是半载条件，用于负载调整标准。 术语 0.01V 反映了 1/2 的反馈阈值磁滞。 但是 R3 值也不能太大，否则电路可能会工作异常。

Board: 4 copper layers, 60.0 x 35.0 mm, 27 parts (1 on the bottom side), 14 nets.

## Commit log

2025-04-17 MP2905
2025-04-17 添加了正交尺寸
